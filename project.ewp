# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: rt-thread\components\net\sal_socket\include\socket\sys_socket; rt-thread\include; rt-thread\components\net\sal_socket\include\dfs_net\sys_select; rt-thread\components\net\sal_socket\include\dfs_net; rt-thread\components\finsh; rt-thread\components\net\at\include; rt-thread\components\net\sal_socket\include\socket; libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc; board\CubeMX_Config\Inc; libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include; libraries\HAL_Drivers\config; libraries\HAL_Drivers; rt-thread\libcpu\arm\common; .; rt-thread\components\drivers\include; board; rt-thread\components\libc\compilers\dlib; rt-thread\components\net\netdev\include; rt-thread\components\drivers\sensors; packages\bh1750-v1.0.0; rt-thread\libcpu\arm\cortex-m3; applications; rt-thread\components\dfs\filesystems\devfs; packages\at_device-latest; rt-thread\components\net\at\at_socket; rt-thread\components\dfs\include; libraries\STM32F1xx_HAL\CMSIS\Include; rt-thread\components\net\sal_socket\impl; rt-thread\components\net\sal_socket\include; rt-thread\components\libc\compilers\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c onenet_sample.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_soft_i2c.c drv_common.c
  group at_device
    packages/at_device-latest/: at_socket_esp8266.c
  group bh1750
    packages/bh1750-v1.0.0/: bh1750.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Sensors
    rt-thread/components/drivers/sensors/: sensor.c sensor_cmd.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/common/: gmtime_r.c
  group dlib
    rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group AT
    rt-thread/components/net/at/src/: at_utils.c at_cli.c at_client.c
    rt-thread/components/net/at/at_socket/: at_socket.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/impl/: af_inet_at.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group STM32_HAL
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_sram.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_i2c.c
